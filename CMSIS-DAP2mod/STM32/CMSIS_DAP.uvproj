# Keil uVision project CMSIS_DAP.uvproj, settings and files
target CMSIS-DAP (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS_DAP +hex
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STM32F103Cx STLINK_V21
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS-DAP
    ./: startup_stm32f10x_md.s system_stm32f10x.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../: JTAG_DP.c SW_DP.c SWO.c DAP_vendor.c DAP.c
  group Lib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c misc.c
  group STM32_USB-FS-Device_Driver
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
